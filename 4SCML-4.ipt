# Autodesk Inventor part: 4SCML-4internetui
## iProperties
Created: 2010-02
Part Number: 4SCML-4internetui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
